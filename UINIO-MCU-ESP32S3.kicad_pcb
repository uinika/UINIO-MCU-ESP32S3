# Repository uinika/UINIO-MCU-ESP32S3

File README.md:

# UINIO-MCU-ESP32S3 核心板

[**UINIO-MCU-ESP32S3**](https://gitee.com/uinika/UINIO-MCU-ESP32S3) 是一款采用 [上海乐鑫科技](https://www.espressif.com.cn) **ESP32-S3** 微控制器的核心板电路设计，该微控制器基于 **Xtensa® dual-core 32-bit LX7** 架构，拥有 45 个 GPIO 接口，主频高达 `240MHz`，同时具备 **2.4GHz Wi-Fi** 与 **Bluetooth5** 两种物联网接入能力。片上载有 `384KB` 容量的 **ROM**，以及 `512KB` 容量的 **SRAM** 和 `16KB` 容量的 **RTCSRAM**。

## 设计概要

- 完整兼容官方的 [Arduino-ESP32](https://docs.espressif.com/projects/arduino-esp32/en/latest/) 板级支持包；
- 采用 LDO 低压差线性稳压芯片 `ME6211C33M5G` 提供 `3.3V` 电源；
- 预留 **TQFN** 封装的 USB 转 UART 串口芯片 **CH343P** 位置，可以按需进行贴装，不贴装时可以采用右上角的 4 线杜邦针外接串口下载模块；
- 预留有 2.4G 微带天线 **π 型阻抗匹配电路**位置，如果对于信号的收发功率没有严格要求，则可以将位号为 `L1` 的串联电感替换为 `0R` 电阻；
- 预留有 5 个 `1mm` 沉头螺丝开孔，可以用于固定主板和外壳；

## 注意事项

1. 上电之前不能下拉 `IO9/BOOT` 的电平状态，否则 **ESP32-S3** 将会进入**下载模式**；
2. `IO8` 引脚默认进行了上拉，因为如果其为低电平状态，则不能使用串口进行固件下载；
3. `GPIO11` 默认为 SPI 接口 Flash 存储器的 `VDD` 引脚，需要配置之后才能作为 GPIO 使用；
4. 外置的 `W25Q128JVSSIQ` 型 Flash 存储器，其 `VDD` 已经连接至 `3.3V` 电源，使用时无需再行配置，Flash 采用普通的两线制 SPI 总线进行通信；
5. `IO12`、`IO13` 在 **QIO** 模式下被复用为 SPI 信号线 `SPIHD` 和 `SPIWP`，本开发板采用两线制 SPI 的 **DIO** 模式，使用时需要注意将 Flash 配置为 **DIO** 模式；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-MCU-ESP32S3 开源项目提供有如下一系列技术参考资料：

1. [《UINIO-MCU-ESP32 核心板电路设计》](http://www.uinio.com/Project/UINIO-MCU-ESP32/)
2. [《基于 UINIO-MCU-ESP32 的 Arduino 进阶教程》](http://www.uinio.com/Project/Arduino-ESP32/)
3. [《运用 U8G2 与 TFT_eSPI 玩转 UINIO-Monitor 显示屏》](http://www.uinio.com/Project/UINIO-Monitor/)
4. [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-MCU-ESP32S3.html)

## KiCad design UINIO-MCU-ESP32S3.kicad_pcb

Parts:
C1, C2, C4, C9, C17, C20: 1uF; C_0402_1005Metric
C3, C7, C11, C12, C13, C14, C18, C19: 0.1uF; C_0402_1005Metric
C6: 10uF; C_0402_1005Metric
C10: 10nF; C_0402_1005Metric
C15, C16: 15pF; C_0402_1005Metric
D1: LED_Red; LED_0603_1608Metric
J1: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J2, J4: Conn_01x27_Pin; PinHeader_1x27_P2.54mm_Vertical
J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
L1: AN9520-245; ANT-SMD_L9.5-W2.1
R1, R2: 5.1K; R_0402_1005Metric
R3: 2K; R_0402_1005Metric
R4, R5, R6, R7, R8, R9: 10K; R_0402_1005Metric
SW1: 复位; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
SW2: 启动选择; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
U1: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: W25Q128JVSSIQ; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL
U3: ESP-PSRAM64H; SOP-8_L4.9-W3.9-P1.27-LS6.0-BL
U4: RS2227XUTQK10; WQFN-10_L1.8-W1.4-P0.40-BL
U5: ESP32-S3
U6: CH343P; TQFN-16_L3.0-W3.0-P0.50-BL-EP1.7
U7: LMBT3904DW1T1G; SOT-363_L2.0-W1.3-P0.65-LS2.1-TL
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y1: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/CH343_USB_Data+: U4.7 (HSD2+), U6.7 (UD+)
/CH343_USB_Data-: U4.6 (HSD2-), U6.8 (UD-)
/CHIP_PU: C7.1, R4.2, SW1.3, SW1.4, U5.4 (CHIP_PU), U7.6 (C)
/DTR: J3.1, R7.1, U6.12 (DTRTNOW), U7.4 (E)
/GPIO0: J2.3, R9.1, SW2.3, SW2.4, U5.5 (GPIO0), U7.3 (C)
/GPIO1: J2.4, U5.6 (GPIO1)
/GPIO2: J2.5, U5.7 (GPIO2)
/GPIO3: J2.6, U5.8 (GPIO3)
/GPIO4: J2.7, U5.9 (GPIO4)
/GPIO5: J2.8, U5.10 (GPIO5)
/GPIO6: J2.9, U5.11 (GPIO6)
/GPIO7: J2.10, U5.12 (GPIO7)
/GPIO8: J2.11, U5.13 (GPIO8)
/GPIO9: J2.12, U5.14 (GPIO9)
/GPIO10: J2.13, U5.15 (GPIO10)
/GPIO11: J2.14, U5.16 (GPIO11)
/GPIO12: J2.15, U5.17 (GPIO12)
/GPIO13: J2.16, U5.18 (GPIO13)
/GPIO14: J2.17, U5.19 (GPIO14)
/GPIO15: J2.18, U5.21 (XTAL_32K_P)
/GPIO16: J2.19, U5.22 (XTAL_32K_N)
/GPIO17: J2.20, U5.23 (GPIO17)
/GPIO18: J2.21, U5.24 (GPIO18)
/GPIO19/ESP32_USB_D-: J2.22, U4.4 (HSD1-), U5.25 (GPIO19)
/GPIO20/ESP32_USB_D+: J2.23, U4.5 (HSD1+), U5.26 (GPIO20)
/GPIO21: J2.24, U5.27 (GPIO21)
/GPIO33: J4.14, U5.38 (GPIO33)
/GPIO34: J4.13, U5.39 (GPIO34)
/GPIO35: J4.12, U5.40 (GPIO35)
/GPIO36: J4.11, U5.41 (GPIO36)
/GPIO37: J4.10, U5.42 (GPIO37)
/GPIO38: J4.9, U5.43 (GPIO38)
/GPIO39: J4.8, U5.44 (MTCK)
/GPIO40: J4.7, U5.45 (MTD0)
/GPIO41: J4.6, U5.47 (MTDI)
/GPIO42: J4.5, U5.48 (MTMS)
/GPIO45: J4.4, R6.2, U5.51 (GPIO45)
/GPIO46: J4.3, U5.52 (GPIO46)
/RTS: J3.4, R8.2, U6.13 (RTS), U7.1 (E)
/SPICLK_N/GPIO48: J4.16, U5.36 (SPICLK_N)
/SPICLK_P/GPIO47: J4.15, U5.37 (SPICLK_P)
/SPICLK/GPIO30: J4.19, U2.6 (CLK), U3.6 (SCLK), U5.33 (SPICLK)
/SPICS0/GPIO29: J4.20, U2.1 (CS#), U5.32 (SPICS0)
/SPICS1/GPIO26: J2.25, U3.1 (CE#), U5.28 (SPICS1)
/SPID/GPIO32: J4.17, U2.5 (DI(IO0)), U3.5 (SI/SIO0), U5.35 (SPID)
/SPIHD/GPIO27: J4.22, U2.7 (HOLD#/RESET#/(IO3)), U3.7 (SIO3), U5.30 (SPIHD)
/SPIQ/GPIO31: J4.18, U2.2 (DO(IO1)), U3.2 (SO/SIO1), U5.34 (SPIQ)
/SPIWP/GPIO28: J4.21, U2.3 (WP#(IO2)), U3.3 (SIO2), U5.31 (SPIWP)
/U0RXD: J3.3, U5.50 (U0RXD), U6.4 (TXD)
/U0TXD: J3.2, U5.49 (U0TXD), U6.5 (RXD)
/USB_Data+: U4.1 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
/USB_Data-: U4.2 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
/VDD_3.3V: C2.2, C3.1, C4.1, C6.1, C9.1, C10.1, C11.2, C12.1, C14.2, C17.1, C19.1, J2.2, J2.26, J4.2, J4.24, R3.2, R4.1, R5.2, R6.1, R9.2, U1.5 (Vout), U4.9 (V+), U5.2 (VDD3P3), U5.3 (VDD3P3), U5.20 (VDD3P3_RTC), U5.46 (VDD3P3_CPU), U5.55 (VDDA), U5.56 (VDDA), U6.1 (VIO), U6.6 (V3)
/VDD_5V: C1.2, C13.2, J4.26, U1.1 (Vin), U1.3 (CE), U6.3 (VDD5), U6.9 (VBUS), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/VDD_SPI/GPIO11: C18.1, C20.1, J4.23, U2.8 (VCC), U3.8 (VCC), U5.29 (VDD_SPI)
GND: C1.1, C2.1, C3.2, C4.2, C6.2, C7.2, C9.2, C10.2, C11.1, C12.2, C13.1, C14.1, C15.1, C16.1, C17.2, C18.2, C19.2, C20.2, D1.1 (K), J1.1, J2.1, J2.27, J4.1, J4.25, J4.27, R1.2, R2.2, SW1.1, SW1.2, SW2.1, SW2.2, U1.2 (Vss), U2.4 (GND), U3.4 (VSS), U4.3 (GND), U4.8 (OE#), U5.57 (GND), U6.2 (GND), U6.17 (EP), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND), Y1.2, Y1.4
unnamed: D1.2 (A), R3.1
unnamed: J1.2, U4.10 (S)
unnamed: J1.3, R5.1
unnamed: R7.2, U7.2 (B)
unnamed: R8.1, U7.5 (B)
unnamed: L1.1, U5.1 (LNA_IN)
unnamed: C16.2, U5.53 (XTAL_N), Y1.3
unnamed: C15.2, U5.54 (XTAL_P), Y1.1
unnamed: R1.1, USB1.A5 (CC1)
unnamed: R2.1, USB1.B5 (CC2)

Notes on the sheet:
ESP32-C3 最小系统
3.3V 线性稳压电路
USB - UART0 下载控制电路
Flash 存储器电路
PSRAM 伪静态随机存储器
USB Type-C 接口电路
2.54mm 间距引脚排针
复位与启动选择按键

Board: 2 copper layers, 87.4 x 20.3 mm, 48 parts (2 on the bottom side), 66 nets.

Other parts of the board:
HOLE**: Hole-1mm
HOLE**#2, HOLE**#3, HOLE**#4: Hole-1mm

## Commit log

2023-02-02 Initializing the project.
2023-02-03 Start schematic drawing.
2023-02-13 Update PCB.
2023-02-20 Complete schematic drawing.
2023-02-20 PCB layout finish.
2023-02-21 Update PCB layout.
2023-02-21 Start wiring.
2023-02-23 Complete PCB wiring.
2023-03-03 Release UINIO-MCU-ESP32S3 version 1.0.0.
2023-03-19 Release UINIO-MCU-ESP32S3 version 2.0.0.
2023-03-26 Fix bug.
2023-04-03 Release UINIO-MCU-ESP32S3 version 3.0.0.
2023-05-11 Re-export the PDF file.
2023-07-06 Release UINIO-MCU-ESP32S3 version 3.1.0.
2023-07-11 Update README.md.
2024-01-10 Release UINIO-MCU-ESP32S3 version 3.1.1.
2024-01-31 Release UINIO-MCU-ESP32S3 version 3.2.1.
2024-03-05 Release UINIO-MCU-ESP32S3 version 3.3.0.
2024-03-29 Release UINIO-MCU-ESP32S3 version 3.5.0.
